# Keil uVision project STM32F103_MBED.uvproj, settings and files
target STM32F103_MBED (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Stm32f103_mbed +hex
  c flags: Optim=1
  c define: TARGET_NUCLEO_F103ZE,  TARGET_M3,  TARGET_STM,  TARGET_STM32F1,  TARGET_STM32F103RB,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1414999514.99,  __MBED__=1,  TARGET_FF_ARDUINO,  TARGET_FF_MORPHO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: ..\mbed-src\api;..\mbed-src\hal;..\mbed-src\targets\hal;..\mbed-src\targets\cmsis;..\mbed-src\targets\cmsis\TARGET_STM;..\mbed-src\targets\cmsis\TARGET_STM\TOOLCHAIN_ARM_MICRO;..\User\delay;..\User\DS18B20;..\User\sys;..\User;..\User\ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\mbed-src\targets\cmsis\TARGET_STM\TOOLCHAIN_ARM_MICRO\stm32f10x.sct
  group Startup
    ../mbed-src/targets/cmsis/TARGET_STM/TOOLCHAIN_ARM_MICRO/: startup_stm32f10x_hd.s
  group User
    ../User/: main.cpp pinbitband.h SysTick.c
  group mbed
    ../mbed-src/targets/hal/: analogin_api.c analogout_api.c device.h gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c mbed_overrides.c objects.h PeripheralNames.h pinmap.c PinNames.h port_api.c PortNames.h pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    ../mbed-src/common/: BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp assert.c board.c error.c exit.c gpio.c mbed_interface.c pinmap_common.c rtc_time.c semihost_api.c us_ticker_api.c wait_api.c
  group Libraries
    ../mbed-src/targets/cmsis/TARGET_STM/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../mbed-src/targets/cmsis/TARGET_STM/: cmsis_nvic.c system_stm32f10x.c
    ../mbed-src/targets/cmsis/TARGET_STM/TOOLCHAIN_ARM_MICRO/: sys.cpp
  group DeviceLib
    ../User/DS18B20/: ds18b20.cpp
    ../User/ESP8266/: ESP8266_Usart.cpp
